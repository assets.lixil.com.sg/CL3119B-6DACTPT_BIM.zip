Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2021-09-21T09:22:32
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Default UI

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcDistributionPort
FlowDirection: SOURCE
Pset_DistributionPortPipe - PortNumber: 1; ConnectionType: WELDED
MEPPortPipe - ProfileShape: ROUND; OuterDiameter: 110 mm; ConnectorDiameter: 110 mm; NominalWidth: 110 mm; NominalHeight: 110 mm

# IfcEnergyConversionDevice: CL3119B-6DACTPT, AmericanStandard_WCWallHung_AcaciaE_(CL3119B-6DACTPT):CL3119B-6DACTPT:3473
In: Level 1
Pset_ManufacturerTypeInformation - ModelReference: CL3119B-6DACTPT; Manufacturer: American Standard; ProductionYear: 2021
Pset_DistributionFlowElementCommon - Reference: CL3119B-6DACTPT
Constraints - Elevation: 0 mm
Dimensions - Area: 0.499304 m2; Volume: 0.0675704 m3
Identity Data - Mark: 1
Mechanical - System Classification: Sanitary
Other - AssetIdentifier: Please record on commissioning; BarCode: Please record on commissioning; Category: Plumbing Fixtures; Family: AmericanStandard_WCWallHung_AcaciaE_(CL3119B-6DACTPT): CL3119B-6DACTPT; Family and Type: AmericanStandard_WCWallHung_AcaciaE_(CL3119B-6DACTPT): CL3119B-6DACTPT; InstallationDate: Please record on commissioning; SerialNumber: Please record on commissioning; Type: AmericanStandard_WCWallHung_AcaciaE_(CL3119B-6DACTPT): CL3119B-6DACTPT; Type Id: AmericanStandard_WCWallHung_AcaciaE_(CL3119B-6DACTPT): CL3119B-6DACTPT; WarrantyStartDate: Please record on commissioning
Phasing - Phase Created: New Construction
Constraints(Type) - Default Elevation: 400 mm
Identity Data(Type) - Assembly Code: C1030200; Description: Acacia E Vortex WH 3/4.5L WT; Keynote: N13; Manufacturer: American Standard; Model: CL3119B-6DACTPT; OmniClass Number: 23.45.05.14.14; OmniClass Title: Sinks/Lavatories; Type Comments: Acacia E Vortex WH 3/4.5L WT; Type Name: CL3119B-6DACTPT; URL: https://www.americanstandard-apac.com/
Model Properties(Type) - _Author: AM; _AuthorizedBy: bimstore; _BimSpecGuid: 0; _BSBibleVersion: 16; _CreatedBy: https://www.bimstore.co; _CurrentRevision: 1; _DistributedBy: https://www.bimstore.co; BIMObjectName: AmericanStandard_WCWallHung_AcaciaE_(CL3119B-6DACTPT); NBSDescription: WC pans; NBSNote: n/a; NBSObjectName: American Standard - WC pans; NBSOfficeMasterTag: n/a; NBSReference: 45-35-70/360
Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; ClassificationName: Uniclass2015; ClassificationValue: Pr_40_20_96_18; CodePerformance: n/a; Color: White; Constituents: n/a; CreatedBy: https://www.americanstandard-apac.com/; CreatedOn: 2021-08-24 T09:00:00; DurationUnit: Year; ExpectedLife: 0; Family Name: AmericanStandard_WCWallHung_AcaciaE_(CL3119B-6DACTPT); Features: n/a; Finish: n/a; Grade: n/a; ManufacturerName: American Standard; Material: n/a; ModelNumber: Acacia E Vortex WH 3/4.5L WT; ModelReference: CL3119B-6DACTPT; ProductionYear: 2021; ReferencedStandard: n/a; ReplacementCost: n/a; Shape: n/a; Size: n/a; TypeName: CL3119B-6DACTPT; WarrantyDescription: n/a; WarrantyDurationLabor: 0; WarrantyDurationParts: 0; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: https://www.americanstandard-apac.com/; WarrantyGuarantorParts: https://www.americanstandard-apac.com/
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
